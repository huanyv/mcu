# Keil uVision project Project.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x00010000) IRAM(0x20000000,0x00005000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\SYSTEM\i2c;..\HARDWARE\key;..\HARDWARE\led;..\HARDWARE\18b20;..\HARDWARE\oled;..\HARDWARE\oled\char inc;..\HARDWARE\ds1302;..\HARDWARE\oled_display
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Core
    ../CORE/: startup_stm32f10x_md.s core_cm3.c
  group Fwlib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_exti.c
  group User
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group Hardware
    ../HARDWARE/led/: led.c
    ../HARDWARE/key/: key.c
    ../HARDWARE/oled/: oled_i2c.c
    ../HARDWARE/18b20/: 18b20.c
    ../HARDWARE/ds1302/: ds1302.c
    ../HARDWARE/oled_display/: oled_display.c
  group System
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/i2c/: i2c.c
  group Readme
    ../: README.txt
