# Keil uVision project Project.uvproj, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x00010000) IRAM(0x20000000,0x00005000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\delay;..\STM32F10x_FWLib\inc;..\HARDWARE\key;..\HARDWARE\led;..\HARDWARE\sys;..\HARDWARE\usart;..\CORE;..\USER
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Hardware
    ../HARDWARE/delay/: delay.c
    ../HARDWARE/key/: key.c
    ../HARDWARE/led/: led.c
    ../HARDWARE/sys/: sys.c
  group Fwlib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c
  group User
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group Core
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
software components: CMSIS:CORE 4.3.0
