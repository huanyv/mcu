# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\DS18B20
  group Source Group 1
    ./: main.c
    ./DS18B20/: DS18B20.c
