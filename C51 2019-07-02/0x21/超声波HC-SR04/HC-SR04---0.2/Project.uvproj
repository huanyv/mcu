# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\LCD1602;.\HC-SR04
  group Source Group 1
    ./: main.c
    ./LCD1602/: lcd1602.c
    ./HC-SR04/: hcsr04.c
  group README
    ./: README.txt
