# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\HARDWARE\INC
  group HARDWARE
    ../HARDWARE/SRC/: buling.c ds18b20.c ds1302.c IIC.c lcd1602.c
  group USER
    ./: main.c
  group Readme
    ../: README.txt
