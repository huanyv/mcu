# Keil uVision project 独立按键4.uvproj, settings and files
target 目标 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 独立按键4 +hex
  c flags: Optimize=8 SizeSpeed=1
  group 源组 1
    ./: 独立按键4.c 独立按键数码管.c 独立按键.c
