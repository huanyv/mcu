# Keil uVision project 11INT0中断计数.uvproj, settings and files
target 目标 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 11INT0中断计数 +hex
  c flags: Optimize=8 SizeSpeed=1
  group 源组 1
    ./: STARTUP.A51 11INT0中断计数.c
