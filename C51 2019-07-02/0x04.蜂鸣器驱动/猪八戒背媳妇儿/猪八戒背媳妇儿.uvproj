# Keil uVision project 猪八戒背媳妇儿.uvproj, settings and files
target 目标 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 猪八戒背媳妇儿 +hex
  c flags: Optimize=8 SizeSpeed=1
  group 源组 1
    ./: 猪八戒背媳妇儿.c
